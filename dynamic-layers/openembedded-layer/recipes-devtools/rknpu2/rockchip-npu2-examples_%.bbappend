# Auto-enable opencv when meta-oe layer is present
PACKAGECONFIG ?= "opencv"
