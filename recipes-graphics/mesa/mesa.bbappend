inherit rockchip_uapi
