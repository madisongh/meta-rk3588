PACKAGECONFIG:append:rockchip = " v4l2"
PACKAGE_ARCH:rockchip = "${RK_PKGARCH}"
