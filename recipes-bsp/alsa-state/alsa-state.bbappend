RDEPENDS:${PN}:append:rk3588 = " rockchip-alsa-ucm-conf"
PACKAGE_ARCH:rk3588 = "${SOC_FAMILY_PKGARCH}"

