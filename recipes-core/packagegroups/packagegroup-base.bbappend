RDEPENDS:packagegroup-base-bluetooth:append:rockchip = " rkwifibt-tools-bluetooth"
RDEPENDS:packagegroup-base-wifi:append:rockchip = " rkwifibt-tools-wifi"
